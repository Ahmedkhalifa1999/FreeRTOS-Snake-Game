# Keil uVision project Snake Game.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Adding Multiple Tasks
  c flags: Optim=1 OneElfS=1 v6Lang=2 wLevel=1
  c define: __EVAL
  c misc: -xc
  c include: C:/ti/TivaWare_C_Series-2.2.0.295
  asm define: __EVAL
  asm include: C:/ti/TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry 0x00000000 --entry Reset_Handler --first __Vectors --summary_stderr --info summarysizes --load_addr_map_info
  group Source
    ./: main.c
  group TivaWare
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Heap 10.4.6, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
